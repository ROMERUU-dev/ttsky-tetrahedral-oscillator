v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N -780 -290 -730 -290 {
lab=#net1}
N -780 -210 -730 -210 {
lab=#net2}
N -880 -290 -830 -290 {
lab=#net1}
N -880 -210 -830 -210 {
lab=#net2}
N -300 -290 -250 -290 {
lab=#net3}
N -400 -290 -350 -290 {
lab=#net3}
N -400 -210 -350 -210 {
lab=#net4}
N -300 -210 -250 -210 {
lab=#net4}
N -670 -320 -670 -170 {
lab=#net3}
N -590 -320 -550 -320 {
lab=#net1}
N -470 -320 -470 -170 {
lab=#net4}
N -590 -170 -550 -170 {
lab=#net2}
N -570 -320 -570 -290 {
lab=#net1}
N -570 -210 -570 -170 {
lab=#net2}
N -490 -290 -400 -290 {
lab=#net3}
N -490 -290 -490 -250 {
lab=#net3}
N -670 -250 -490 -250 {
lab=#net3}
N -440 -210 -400 -210 {
lab=#net4}
N -440 -250 -440 -210 {
lab=#net4}
N -470 -250 -440 -250 {
lab=#net4}
N -730 -290 -570 -290 {
lab=#net1}
N -730 -210 -570 -210 {
lab=#net2}
N -910 -210 -880 -210 {
lab=#net2}
N -910 -290 -880 -290 {
lab=#net1}
N -810 -290 -780 -290 {
lab=#net1}
N -830 -290 -810 -290 {
lab=#net1}
N -810 -210 -780 -210 {
lab=#net2}
N -830 -210 -810 -210 {
lab=#net2}
N -350 -290 -320 -290 {
lab=#net3}
N -320 -290 -300 -290 {
lab=#net3}
N -350 -210 -320 -210 {
lab=#net4}
N -320 -210 -300 -210 {
lab=#net4}
N -250 -210 -220 -210 {
lab=#net4}
N -250 -290 -220 -290 {
lab=#net3}
N -810 -400 -810 -370 {
lab=#net5}
N -320 -400 -320 -370 {
lab=#net6}
N -810 -130 -810 -100 {
lab=#net7}
N -320 -130 -320 -100 {
lab=#net8}
N -990 -290 -970 -290 {
lab=VGND}
N -990 -210 -970 -210 {
lab=VGND}
N -160 -290 -140 -290 {
lab=VGND}
N -160 -210 -140 -210 {
lab=VGND}
N -970 -320 -970 -290 {
lab=VGND}
N -970 -350 -970 -320 {
lab=VGND}
N -970 -380 -970 -350 {
lab=VGND}
N -910 -320 -910 -290 {
lab=#net1}
N -910 -350 -910 -320 {
lab=#net1}
N -910 -380 -910 -350 {
lab=#net1}
N -970 -210 -970 -180 {
lab=VGND}
N -970 -180 -970 -150 {
lab=VGND}
N -970 -150 -970 -120 {
lab=VGND}
N -910 -210 -910 -180 {
lab=#net2}
N -910 -180 -910 -150 {
lab=#net2}
N -910 -150 -910 -120 {
lab=#net2}
N -220 -320 -220 -290 {
lab=#net3}
N -220 -350 -220 -320 {
lab=#net3}
N -220 -380 -220 -350 {
lab=#net3}
N -160 -320 -160 -290 {
lab=VGND}
N -160 -350 -160 -320 {
lab=VGND}
N -160 -380 -160 -350 {
lab=VGND}
N -220 -210 -220 -180 {
lab=#net4}
N -220 -180 -220 -150 {
lab=#net4}
N -220 -150 -220 -120 {
lab=#net4}
N -160 -210 -160 -180 {
lab=VGND}
N -160 -180 -160 -150 {
lab=VGND}
N -160 -150 -160 -120 {
lab=VGND}
C {sky130_stdcells/inv_1.sym} -730 -250 1 0 {name=x1 VGND=VGND VNB=VGND VPB=VDPWR VPWR=VDPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_2.sym} -780 -250 1 0 {name=x2 VGND=VGND VNB=VGND VPB=VDPWR VPWR=VDPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_2.sym} -830 -250 3 0 {name=x3 VGND=VGND VNB=VGND VPB=VDPWR VPWR=VDPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} -880 -250 3 0 {name=x4 VGND=VGND VNB=VGND VPB=VDPWR VPWR=VDPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} -250 -250 1 0 {name=x5 VGND=VGND VNB=VGND VPB=VDPWR VPWR=VDPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_2.sym} -300 -250 1 0 {name=x6 VGND=VGND VNB=VGND VPB=VDPWR VPWR=VDPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_2.sym} -350 -250 3 0 {name=x7 VGND=VGND VNB=VGND VPB=VDPWR VPWR=VDPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} -400 -250 3 0 {name=x8 VGND=VGND VNB=VGND VPB=VDPWR VPWR=VDPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_4.sym} -630 -320 0 0 {name=x9 VGND=VGND VNB=VGND VPB=VDPWR VPWR=VDPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_4.sym} -510 -320 0 0 {name=x10 VGND=VGND VNB=VGND VPB=VDPWR VPWR=VDPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_4.sym} -510 -170 2 0 {name=x11 VGND=VGND VNB=VGND VPB=VDPWR VPWR=VDPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_4.sym} -630 -170 2 0 {name=x12 VGND=VGND VNB=VGND VPB=VDPWR VPWR=VDPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_16.sym} -810 -330 3 0 {name=x13 VGND=VGND VNB=VGND VPB=VDPWR VPWR=VDPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_16.sym} -320 -330 3 0 {name=x14 VGND=VGND VNB=VGND VPB=VDPWR VPWR=VDPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_16.sym} -810 -170 1 0 {name=x15 VGND=VGND VNB=VGND VPB=VDPWR VPWR=VDPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_16.sym} -320 -170 1 0 {name=x16 VGND=VGND VNB=VGND VPB=VDPWR VPWR=VDPWR prefix=sky130_fd_sc_hd__ }
C {sky130_fd_pr/cap_mim_m3_1.sym} -940 -290 1 0 {name=C1 model=cap_mim_m3_1 W=30 L=30 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -940 -210 1 0 {name=C2 model=cap_mim_m3_1 W=30 L=30 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -190 -290 3 0 {name=C3 model=cap_mim_m3_1 W=30 L=30 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -190 -210 3 0 {name=C4 model=cap_mim_m3_1 W=30 L=30 MF=1 spiceprefix=X}
C {gnd.sym} -990 -290 1 0 {name=l1 lab=VGND}
C {gnd.sym} -990 -210 1 0 {name=l2 lab=VGND}
C {gnd.sym} -140 -290 3 0 {name=l3 lab=VGND}
C {gnd.sym} -140 -210 3 0 {name=l4 lab=VGND}
C {sky130_fd_pr/cap_mim_m3_1.sym} -940 -320 1 0 {name=C5 model=cap_mim_m3_1 W=30 L=30 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -940 -350 1 0 {name=C6 model=cap_mim_m3_1 W=30 L=30 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -940 -380 1 0 {name=C7 model=cap_mim_m3_1 W=30 L=30 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -940 -180 1 0 {name=C8 model=cap_mim_m3_1 W=30 L=30 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -940 -150 1 0 {name=C9 model=cap_mim_m3_1 W=30 L=30 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -940 -120 1 0 {name=C10 model=cap_mim_m3_1 W=30 L=30 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -190 -320 3 0 {name=C11 model=cap_mim_m3_1 W=30 L=30 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -190 -350 3 0 {name=C12 model=cap_mim_m3_1 W=30 L=30 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -190 -380 3 0 {name=C13 model=cap_mim_m3_1 W=30 L=30 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -190 -180 3 0 {name=C14 model=cap_mim_m3_1 W=30 L=30 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -190 -150 3 0 {name=C15 model=cap_mim_m3_1 W=30 L=30 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -190 -120 3 0 {name=C16 model=cap_mim_m3_1 W=30 L=30 MF=1 spiceprefix=X}
C {iopin.sym} -640 -420 0 0 {name=p1 lab=VGND
}
C {iopin.sym} -640 -390 0 0 {name=p2 lab=VDPWR}
